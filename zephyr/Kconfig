## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0

config NNG
	bool "Enable support for nng"
```
